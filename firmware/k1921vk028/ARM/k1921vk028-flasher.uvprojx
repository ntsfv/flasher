# Keil uVision project k1921vk028-flasher.uvprojx, settings and files
target template (6230000::V6.23::ARMCLANG)
  device: K1921VK028 Generic
  pack: NIIET.K1921VK028_DFP.1.1.4
  cpu: IRAM(0x20000000,0xA0000) IRAM2(0x13000000,0x10000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1921vk028_bootloader_8MHz +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RETARGET, RETARGET_USE_UART, SYSCLK_PLL, CKO_NONE, OSECLK_VAL=8000000
  c include: ..\platform\CMSIS\Core\Include;..\platform\Device\NIIET\K1921VK028\Include;..\platform\retarget;..\platform\retarget\Template\K1921VK028
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x13000000 size 0x10000
  group startup
    ../platform/Device/NIIET/K1921VK028/Source/ARM/: startup_K1921VK028.s
    ../platform/Device/NIIET/K1921VK028/Source/: system_K1921VK028.c
  group src
    ../app/: main.c boot_core.c boot_flash.c boot_packet.c
